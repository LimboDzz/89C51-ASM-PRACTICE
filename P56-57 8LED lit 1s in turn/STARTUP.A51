		ORG 00H
		SJMP MAIN
		ORG 0BH
		SJMP TIMER0
MAIN:
		MOV A,#00000001B	;P0 LED
		MOV P0,A
		MOV R0,#50			;20ms*50
		
		MOV TMOD,#00000001B	;T0M1
		MOV TH0,#0B1H		;INIT T0 20MS
		MOV TL0,#0E0H
		
		SETB EA
		SETB ET0
		SETB TR0
		
		SJMP $

TIMER0:
		MOV TH0,#0B1H		;INIT T0 20MS
		MOV TL0,#0E0H
		DJNZ R0,J1
		ACALL ROLL
J1:
		RETI

ROLL:
		MOV R0,#50			;20ms*50
		RL A
		MOV P0,A
		RET
END